Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: COMTI grille d
Time: 2020-07-03T12:01:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: COMT-GRI-120-003_Default (3)
In: Default Storey
Material: FGS 400-15

# IfcBeam: COMT-GRI-MUL-002_Default
In: Default Storey
Material: FGS 400-15

# IfcBuildingElementProxy: COMT-GRI-120-003_Default
In: Default Storey
Material: FGS 400-15
PSet_Mass_Property - Mass Measure: 107.566; Area Measure: 3.07886; Volume Measure: 0.0149504

# IfcBuildingElementProxy: COMT-GRI-MUL-002_Default (3)
In: Default Storey
Material: FGS 400-15
