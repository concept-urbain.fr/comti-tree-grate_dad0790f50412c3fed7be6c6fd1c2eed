Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: COMTI grille d
Time: 2020-07-03T12:03:31
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: COMT-GRI-D120-003_Default (3)
In: Default Storey
Material: Fonte malléable
Name
COMT-GRI-D120-003_Default | PSet_Mass_Property - Mass Measure: 78.9592; Area Measure: 2.29243; Volume Measure: 0.0107784
2 x COMT-GRI-D120-003_Default

# IfcBeam: COMT-GRI-MUL-001_Default (2)
In: Default Storey
Material: S 235

# IfcBeam: COMT-GRI-MUL-002_Default
In: Default Storey
Material: FGS 400-15

# IfcBuildingElementProxy: COMT-GRI-D120-002_Ø 1200 X 600
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: COMT-GRI-D120-003_Default
In: Default Storey
Material: Fonte malléable

# IfcBuildingElementProxy: COMT-GRI-MUL-001_Default (3)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: COMT-GRI-MUL-002_Default (3)
In: Default Storey
Material: FGS 400-15
